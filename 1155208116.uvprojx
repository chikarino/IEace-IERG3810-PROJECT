# Keil uVision project 1155208116.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _1155208116 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_lib
    ./Fw_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Board
    ./Board/: IERG3810_Buzzer.c IERG3810_Buzzer.h IERG3810_KEY.c IERG3810_KEY.h IERG3810_LED.c IERG3810_LED.h IERG3810_Clock.c IERG3810_Clock.h IERG3810_USART.c IERG3810_USART.h IERG3810_TFTLCD.h IERG3810_TFTLCD.c IERG3810_EXTI.h IERG3810_EXTI.c IERG3810_NVIC.h IERG3810_NVIC.c Delay.c Delay.h FONT.H CFONT.h SysTick.c SysTick.h GameState.c GameState.h Menu.c Menu.h BootScreen.c BootScreen.h PS2Keyboard.c PS2Keyboard.h Play.c Play.h Resource.c Resource.h Enemy.c Enemy.h Bullet.c Bullet.h Collision.c Collision.h GameUI.c GameUI.h Stage.c Stage.h GameOver.c GameOver.h Explosion.c Explosion.h Audio.h Audio.c Background.c Background.h th06_06.h JoyPad.c JoyPad.h
  group User
    ./User/: exp1_1.c stm32f10x_it.c exp1_2.c exp1_3.c exp1_4.c exp1_5.c exp2_1.c exp2_1_gpt.cpp exp2_2.c exp2_3.c exp2_4.c exp3_1.c exp3_2.c exp3_3.c exp3_4.c exp3_5.c exp4_1.c exp4_2.c exp4_4.c exp4_5.c exp4_5chat.c exp5_1.c exp5_2.c exp5_3.c exp5_4.c exp5_5.c exp5_6.c exp5_7.c miniProjectMain.c
    ./user/: exp4_3.c
